Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2022-03-09T09:19:43
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (2)
Name | FlowDirection
 | SOURCE
 | SINK

# IfcFlowTerminal: ZA-50011-M-8030
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: ZA-50011-M-8030; Light output ratio: 1; Luminous flux: 4179 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 4179 lm; LightEmitterNominalPower: 40 W; Spectrum: 380: 3690569940095, 385: 4417827229087, 390: 103848623026, 395: 2413660876001, 400: 1635812461327, 405: 4979578862755, 410: 12008388049112, 415: 19010183755416, 420: 43492384284535, 425: 92387686399588, 430: 170081055352913, 435: 269257868050557, 440: 40380870835791, 445: 53053129979791, 450: 541210894212732, 455: 426035362969713, 460: 319709451836581, 465: 266258975756854, 470: 226744256316502, 475: 207655744220688, 480: 216725827235634, 485: 242313897411951, 490: 279103409927536, 495: 328329280608539, 500: 378364184545817, 505: 420767841360709, 510: 462021280818343, 515: 499628684012278, 520: 53600339508975, 525: 569109151908192, 530: 601715266536285, 535: 639788059693626, 540: 661953558922068, 545: 700811371799149, 550: 726341656016481, 555: 763989655672423, 560: 798739391155653, 565: 823807606707386, 570: 857424658565251, 575: 884129681820959, 580: 923657720451389, 585: 931100423923485, 590: 9394705544887, 595: 955178378620732, 600: 987139827132279, 605: 994081671981375, 610: 979624106749581, 615: 966308697952284, 620: 932083700929844, 625: 905082811260578, 630: 85331256109502, 635: 812867663499088, 640: 772044579830947, 645: 723717028028327, 650: 667977465880293, 655: 605503400426768, 660: 557213452509668, 665: 512777944144936, 670: 456803100163102, 675: 410601427321495, 680: 369369935082491, 685: 329151369897868, 690: 292549661602736, 695: 26125055859854, 700: 235075104418585, 705: 201009171723973, 710: 171700611576055, 715: 153226696188552, 720: 134667771647789, 725: 105256592587452, 730: 9695868067302, 735: 84328451897198, 740: 75702721075612, 745: 61935410416435, 750: 55940253582514, 755: 47738579126093, 760: 40479643762502, 765: 36799415163306, 770: 29784469641817, 775: 28115994214981, 780: 32447745650972; ColorTemperature: 3000 K; ColorRenderingIndex: 80

# IfcFlowTerminal: ZAAB 2 Floodlights,projectors
In: Default Building
Type - Description: - Lamp COB - CRI Ra > 80 - MacAdam Ellipse 3 SDCM - Colour 3000K , 4000K - Die-cast aluminium housing - Pre-treated before powder coating ensuring high corrosion resistance - Single cable entry, through wiring upon request - Stainless steel fasteners in grade 304 with zinc flake coating (ZFC) - Durable silicone rubber gasket - High-efficiency optical reflector - Clear toughened glass - Integral control gear; PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: ZAAB, Floodlights,projectors; Housing color: White, Black, Silver
General Information - Article number: ZA-50011-M-8030; Article name: ZAAB 2 Floodlights,projectors; Weight: 3.7 kg; Case height: 33.1 cm; Case diameter: 17 cm; Uld creation date: 03.09.2022 00:00:00
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 40 W
Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 40 W; LightFixtureMountingType: Standing; LightFixturePlacingType: Floor; ManufacturersSpecificInformation: LIGMAN
